# IAR project Charge.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_MD; SKY_DEBUG; WDOG_EN; S2_OUT_EN
  ICCSTM8.CCIncludePath2: ; Lib\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Charge.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\project\Apollo\code\IAP_Code\IAP\PROJECT\lnkstm8l151k4.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: STM8L15X_MD; WDOG_EN
  ICCSTM8.CCIncludePath2: Lib\inc; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Liv08C.hex
  ILINK.IlinkIcfFile: lnkstm8l151k4_V3.icf
  group (top)
    ./: battery.c battery.h charge.c charge.h comm.c flash.c help.c keyproc.c led.c led.h main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h time.c time.h usart.c usart.h
  group Lib/inc
    Lib/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_exti.h stm8l15x_gpio.h stm8l15x_iwdg.h stm8l15x_tim2.h stm8l15x_tim4.h
  group Lib/src
    Lib/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_pwr.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wwdg.c
